# Keil uVision project SmartHome.uvproj, settings and files
target Project (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: SmartHome +hex
  c flags: Optimize=8 SizeSpeed=1
  group user
    ./: IOConfig.h LCD12864.h LCD12864.c KeyScan.h KeyScan.c Delay.h Delay.c I2C.h I2C.c main.c DS3231.h DS3231.c GSM.h GSM.c
